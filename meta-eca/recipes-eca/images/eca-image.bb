include recipes-eca/images/eca-image.inc

PV = "0.2"
PR = "r1"
