PACKAGECONFIG[bluez5] = "--enable-bluetooth,--disable-bluetooth,bluez5"
