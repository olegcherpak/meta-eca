FILESEXTRAPATHS_append := ":${THISDIR}/files"
SRC_URI += "file://defconfig"
