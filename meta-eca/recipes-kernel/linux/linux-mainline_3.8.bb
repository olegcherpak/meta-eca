# This is currently empty and only here so that bitbake
# does not complain
LICENSE = "GPLv2"
