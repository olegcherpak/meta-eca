# Broadcom wifi driver for the 43340 used in Edison

KERNEL_MODULE_PROBECONF_append = " bcm4334x"
