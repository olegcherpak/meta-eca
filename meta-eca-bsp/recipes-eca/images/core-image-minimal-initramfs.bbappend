IMAGE_INSTALL_clanton = "initramfs-live-boot busybox base-passwd udev"
IMAGE_INSTALL_clanton += "kernel-module-usb-storage"
IMAGE_INSTALL_clanton += "kernel-module-ehci-hcd kernel-module-ehci-pci kernel-module-ohci-hcd"
IMAGE_INSTALL_clanton += "kernel-module-stmmac"
